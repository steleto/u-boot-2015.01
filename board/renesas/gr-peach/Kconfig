## board/renesas/gr-peach/Kconfig
```kconfig
if TARGET_GR_PEACH

config SYS_BOARD
	default "gr-peach"

config SYS_VENDOR
	default "renesas"

config SYS_CONFIG_NAME
	default "gr-peach"

endif
```
